# IAR project contiki_cc2530.ewp, settings and files
configuration hello-world (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: UIP_CONF_IPV6=1
  ICC8051.CCDiagSuppress: pe177,pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\; ..\..\..\core\; ..\..\..\core\cfs\; ..\..\..\core\ctk\; ..\..\..\core\dev\; ..\..\..\core\lib\; ..\..\..\core\loader\; ..\..\..\core\net\; ..\..\..\core\net\rpl\; ..\..\..\core\net\mac\; ..\..\..\core\net\rime\; ..\..\..\core\net\routing\; ..\..\..\core\sys\; ..\..\..\cpu\; ..\..\..\cpu\cc253x\; ..\..\..\cpu\cc253x\dev\; ..\..\..\platform\; ..\..\..\platform\cc2530dk\; ..\..\..\platform\cc2530dk\dev\; ..\..\..\examples\cc2530dk\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration blink-hello (8051, debug)
  as the first configuration, except:
configuration timer-test (8051, debug)
  as the first configuration, except:
configuration sensors-demo (8051, debug)
  as the first configuration, except:
configuration udp-server (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: UIP_CONF_IPV6=1; UIP_CONF_RPL=1; PROJECT_CONF_H
  ICC8051.CCIncludePath2: ..\..\; ..\..\..\core\; ..\..\..\core\cfs\; ..\..\..\core\ctk\; ..\..\..\core\dev\; ..\..\..\core\lib\; ..\..\..\core\loader\; ..\..\..\core\net\; ..\..\..\core\net\rpl\; ..\..\..\core\net\mac\; ..\..\..\core\net\rime\; ..\..\..\core\net\routing\; ..\..\..\core\sys\; ..\..\..\cpu\; ..\..\..\cpu\cc253x\; ..\..\..\cpu\cc253x\dev\; ..\..\..\platform\; ..\..\..\platform\cc2530dk\; ..\..\..\platform\cc2530dk\dev\; ..\..\..\examples\cc2530dk\; ..\..\..\examples\cc2530dk\5.udp-ipv6
configuration udp-client (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: PROJECT_CONF_H; UIP_CONF_IPV6=1; UIP_CONF_RPL=1
  ICC8051.CCIncludePath2: as above
  group core/dev
    ../../../core/dev/: leds.c nullradio.c serial-line.c slip.c
  group core/lib
    ../../../core/lib/: assert.c checkpoint.c crc16.c ifft.c list.c me.c memb.c mmem.c print-stats.c random.c ringbuf.c sensors.c settings.c trickle-timer.c
  group core/net
    ../../../core/net/: dhcpc.c hc.c nbr-table.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    ../../../core/net/mac/: contikimac.c csma.c ctdma_mac.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c tdma_mac.c xmac.c
  group core/net/rime
    ../../../core/net/rime/: rimeaddr.c rimestats.c timesynch.c
  group core/net/rpl
    ../../../core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-timers.c rpl.c
  group core/sys
    ../../../core/sys/: autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group cpu/cc253x
    ../../../cpu/cc253x/: 8051def.h cc253x.h rtimer-arch.c soc.c
  group cpu/cc253x/dev
    ../../../cpu/cc253x/dev/: cc2530-rf.c clock.c dma.c dma_intr.c random.c uart-intr.c uart0.c uart1.c watchdog.c
  group examples/blink-hello
    ../../../examples/cc2530dk/2.blink_hello/: blink-hello.c
  group examples/hello-world
    ../../../examples/cc2530dk/1.hello-world/: hello-world.c
  group examples/sensosr-demo
    ../../../examples/cc2530dk/4.sensors-demo/: sensors-demo.c
  group examples/timer-test
    ../../../examples/cc2530dk/3.timer-test/: timer-test.c
  group examples/udp-client
    ../../../examples/cc2530dk/5.udp-ipv6/: client.c ping6.c
  group examples/udp-server
    ../../../examples/cc2530dk/5.udp-ipv6/: server.c
  group platform/cc2530dk
    ../../../platform/cc2530dk/: contiki-conf.h contiki-main.c debug.c putchr.c viztool.c
  group platform/cc2530dk/dev
    ../../../platform/cc2530dk/dev/: adc-sensor.c button-sensor.c leds-arch.c slip-arch.c smartrf-sensors.c
    ../../../platform/cc2530dk/: debug.h
