<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\contiki_cc2530.ewp</path>
  </project>
  <batchBuild/>
</workspace>


